# Keil uVision project TGUI.uvprojx, settings and files
target TGUI (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\User\SDRAM;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\portable\Keil;..\FreeRTOS\portable;..\TGUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\stm32f4Demo.sct
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../User/: main.cpp stm32f4xx_it.c
    ../User/DelayTemp/: DelayTemp.c
    ../User/FLASH/: FLASHConfig.c
    ../User/LCD/: LCDConfig.c
    ../User/LED/: LEDConfig.c
    ../User/SDRAM/: SDRAMConfig.c
    ../User/USART/: USARTConfig.c
    ../User/TOUCH/: gt9xx.c palette.c touch_i2c.c
    ../User/SDIO/: SDCardConfig.c
  group Tgui
    ../TGUI/interface_conf/: tgui_conf.c
    ../TGUI/: rootWin.cpp controlWin.cpp buttonWin.cpp mainWin.cpp staticFrameWin.cpp createWin.cpp listBarWin.cpp optionWin.cpp trackBarWin.cpp textBarWin.cpp progressBarWin.cpp pictureBoxWin.cpp radioBtnWin.cpp trackTextWin.cpp virKeyboardWin.cpp comboBoxWin.cpp dialogWin.cpp
  group Fatfs
    ../User/FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group Font
    ../User/FONT/: fonts.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_portable
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Test
    ../User/Test/: FsTest.c LCDPalette.c LCDTest.c SDRAMTest.c
